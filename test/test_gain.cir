V1 0 INPUT 10
A1 INPUT OUTPUT gain 10
R1 OUTPUT 0 10
.op
