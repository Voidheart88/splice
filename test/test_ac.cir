V1 0 1 10 ac 1
R1 1 2 1000
C1 2 0 0.000001
.ac 1 1000 10
