V1 0 1 1 ac 1
R1 1 2 1000
C1 2 0 0.000001
.ac 10 1000 100
