V1 0 1 10
V2 0 3 10
R1 1 2 abc
R2 2 0 10
R3 3 2 10
.op
