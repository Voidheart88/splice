V1 0 1 10
V2 0 2 10
R1 2 3 10000
M1 1 3 0
.dc V1 0 10 0.2
