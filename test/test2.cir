V1 0 1 10
R1 1 2 10
D1 2 0
.op
