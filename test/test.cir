V1 0 RNODE 10
R1 RNODE 0 10
.op
