V1 0 1 0.5
R1 1 2 10
R2 2 0 10
.op
