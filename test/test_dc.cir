V1 0 1 10
D1 1 0
R2 1 3 10
R3 3 0 10

.dc V1 0 0.8 0.001
