V1 0 1 10
R1 1 3 1
D1 3 0
R2 1 2 10
R3 2 0 10
.dc V1 0 1.5 0.01
.out 3
