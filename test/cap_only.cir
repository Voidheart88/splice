V1 0 1 1 ac 1
C1 1 0 0.000001
.ac 1 100 10
