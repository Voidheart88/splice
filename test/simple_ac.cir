V1 0 1 1 ac 1
R1 1 0 1000
.ac 1 100 10
