Vin 1 0 10
R1 1 2 1000
G1 3 0 2 0 0.01
.op
