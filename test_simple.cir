Vin 1 0 10
R1 1 0 1000
.op
