V1 0 1 10
V2 0 2 20
R1 1 2 10
.op
