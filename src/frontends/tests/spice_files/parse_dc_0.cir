V1 0 1 10
R1 1 2 1000
R2 2 0 1000
.dc V1 1 10 0.1
