V1 0 1 10
V2 0 2 10
M1 1 2 0
.dc V0 0 5 0.1
