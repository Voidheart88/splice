V1 0 1 10 AC 1
R1 1 2 10
R2 2 0 10
.ac 1 1000 10
