V1 0 1 10
V2 0 3 10
R1 1 2 1000
R2 3 2 1000
R3 2 0 1000
.dc V1 1 10 0.1 V2 1 10 0.1
